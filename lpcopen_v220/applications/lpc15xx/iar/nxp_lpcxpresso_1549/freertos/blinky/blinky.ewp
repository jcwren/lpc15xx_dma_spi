# IAR project blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1549 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\..\software\freertos\freertoslpc; ..\..\..\..\examples\freertos\blinky
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M3
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx; ..\..\..\..\examples\freertos\blinky
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/freertos/blinky/: readme.txt
  group example
    ../../../../examples/freertos/blinky/: freertos_blinky.c
    ../../../../startup_code/: iar_startup_lpc15xx.s sysinit.c
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/iar_output/Exe/: board_nxp_lpcxpresso_1549.a
    ../../../../../../software/lpc_core/lpc_chip/chip_15xx/iar_output/chip_15xx_lib/Exe/: chip_15xx_lib.a
