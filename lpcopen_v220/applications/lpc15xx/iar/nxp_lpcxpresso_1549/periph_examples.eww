<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\lib_lpc_chip_15xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549\lib_lpc_board_nxp_lpcxpresso_1549.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\acmp\acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\adc\adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\adc_rom\adc_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ccan_rom\ccan_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ccan_open_rom\ccan_open_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\clkout\clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\crc\crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\dac\dac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\dma_mem\dma_mem.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\dma_rom_uart\dma_rom_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\dma_uart\dma_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\eeprom\eeprom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\flashiap\flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\grouped_int\grouped_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2c_rom_interrupt\i2c_rom_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2c_rom_interrupt_slave\i2c_rom_interrupt_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2c_rom_polling\i2c_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2cm_interrupt\i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2cm_polling\i2cm_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\i2cs_interrupt\i2cs_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\iap\iap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\mrt\mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\pinint\pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\pmu\pmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\pmu_rom\pmu_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\ritimer\ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\rtc\rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\sct_pwm\sct_pwm.ewp</path>
  </project>  
  <project>
    <path>$WS_DIR$\periph\spi_interrupt\spi_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\spi_polling\spi_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\spi_rom_interrupt\spi_rom_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\spi_rom_interrupt_slave\spi_rom_interrupt_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\spi_rom_polling\spi_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\spi_rom_polling_slave\spi_rom_polling_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\systick\systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\temp\temp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\uart_rb\uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\uart_rom_int\uart_rom_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\uart_rom_polling\uart_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\wwdt\wwdt.ewp</path>
  </project>
  <batchBuild>
  </batchBuild>
</workspace>


