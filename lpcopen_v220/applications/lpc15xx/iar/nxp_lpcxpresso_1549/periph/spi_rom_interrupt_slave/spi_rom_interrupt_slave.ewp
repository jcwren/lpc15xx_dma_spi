# IAR project spi_rom_interrupt_slave.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1549 (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M3
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx
  OBJCOPY.OOCOutputFile: periph_spi_rom_interrupt_slave.bin
  ILINK.IlinkOutputFile: periph_spi_rom_interrupt_slave.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/periph/spi_rom_interrupt_slave/: readme.txt
  group example
    ../../../../startup_code/: iar_startup_lpc15xx.s sysinit.c
    ../../../../examples/periph/spi_rom_interrupt_slave/: spi_rom_interrupt_slave.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/iar_output/Exe/: board_nxp_lpcxpresso_1549.a
    ../../../../../../software/lpc_core/lpc_chip/chip_15xx/iar_output/chip_15xx_lib/Exe/: chip_15xx_lib.a
