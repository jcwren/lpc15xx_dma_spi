# Keil uVision project freqmeas.uvprojx, settings and files
target iflash_nxp_lpcxpresso_1549 (ARM-ADS)
  device: LPC1549 NXP (founded by Philips)
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: periph_freqmeas
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group example
    ../../../../startup_code/: sysinit.c keil_startup_lpc15xx.s
    ../../../../examples/periph/freqmeas/: freqmeas.c readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_15xx/keil_output/chip_15xx_lib/: chip_15xx_lib.lib
    ../../../../../../software/lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/keil_output/: board_nxp_lpcxpresso_1549.lib
